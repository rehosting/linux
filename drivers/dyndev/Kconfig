## drivers/dyndev/Kconfig
```kconfig
config DYNDEV
	bool "Dynamic Devices"
	help
		Changes to support dynamic devices
```
